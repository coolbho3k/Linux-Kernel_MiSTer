## drivers/hid/ftec/Kconfig
```kconfig
config HID_FTEC
        tristate "Fanatec Wheels"
        depends on USB_HID
        help
          Support Fanatec racing wheels.
```
